## tests/hwlink/testcase.yaml
```yaml
tests:
  app.unit:
    platform_allow:
      - native_sim
    tags:
      - hwlink
      - led-pattern
      - unit
```
